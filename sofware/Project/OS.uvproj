# Keil uVision project OS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: OS
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER STM32F10X_HD
  c include: ..\APP;..\STMLIB\inc;..\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../APP/: main.c app_led.c
  group LIB
    ../STMLIB/startup/: cstartup.s
    ../STMLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c
  group OS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
