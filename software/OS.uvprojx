# Keil uVision project OS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER
  c include: .\src\app;.\src\common;.\src\FreeRTOS\include;.\src\hal\inc;.\src\mid\inc;.\src\STMLIB\inc;.\src\Lwip-1.3.2\src\include;.\src\Lwip-1.3.2\src\include\ipv4\lwip;.\src\Lwip-1.3.2\src\include\lwip;.\src\Lwip-1.3.2\src\include\netif;.\src\Lwip-1.3.2;.\src\Lwip-1.3.2\src\arch;.\src\Lwip-1.3.2\src\include\ipv4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./src/app/: app_buz.c app_cli.c app_data.c app_display.c app_led.c main.c app_th.c app_time.c netconfig.c
  group mid
    ./src/mid/: mid_th.c mid_cli.c mid_dbg.c mid_rtc.c mid_kalman.c
  group hal
    ./src/hal/: hal_sht10.c bsp.c hal_cli.c hal_uart.c hal_ds3231.c dm9000x.c
    ./src/hal/common/: i2c_bus.c
  group FWLIB
    ./src/STMLIB/startup/: cstartup.s
    ./src/STMLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c
  group FreeRTOS
    ./src/FreeRTOS/: list.c queue.c tasks.c timers.c
    ./src/FreeRTOS/portable/MemMang/: heap_2.c
    ./src/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group lwip-core
    ./src/Lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip-ipv4
    ./src/Lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-netif
    ./src/Lwip-1.3.2/src/netif/: etharp.c ethernetif.c
    ./src/Lwip-1.3.2/src/arch/: sys_arch.c
    ./src/Lwip-1.3.2/src/api/: sockets.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
software components: CMSIS:CORE 5.1.1
