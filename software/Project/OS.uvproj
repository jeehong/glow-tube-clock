# Keil uVision project OS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: OS +hex
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER STM32F10X_HD
  c include: ..\APP;..\STMLIB\inc;..\FreeRTOS\include;..\BSP;..\Lwip-1.3.2\src\arch;..\Lwip-1.3.2\src\include;..\Lwip-1.3.2\src\include\ipv4;..\Lwip-1.3.2\src\include\lwip;..\Lwip-1.3.2\src\include\netif;..\Lwip-1.3.2\src\include\arch;..\Lwip-1.3.2;..\Lwip-1.3.2\src\LwIPEntry;..\Lwip-1.3.2\src\api;..\Lwip-1.3.2\src\include\ipv4\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../APP/: main.c app_led.c netconfig.c app_serial.c
  group BSP
    ../BSP/: bsp.c dm9000x.c i2c_bus.c
  group FWLIB
    ../STMLIB/startup/: cstartup.s
    ../STMLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c misc.c stm32f10x_usart.c stm32f10x_exti.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group LwIP-netif
    ../Lwip-1.3.2/src/netif/: ethernetif.c etharp.c
    ../Lwip-1.3.2/src/arch/: sys_arch.c
  group LwIP-CORE
    ../Lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP-IPV4
    ../Lwip-1.3.2/src/core/ipv4/: icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP-Entry
    ../Lwip-1.3.2/src/LwIPEntry/: LwIPEntry.c
    ../Lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
