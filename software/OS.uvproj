# Keil uVision project OS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: OS +hex
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102 USE_STDPERIPH_DRIVER STM32F10X_HD
  c include: .\src\app;.\src\common;.\src\FreeRTOS\include;.\src\hal\inc;.\src\mid\inc;.\src\STMLIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./src/app/: app_buz.c app_cli.c app_data.c app_display.c app_led.c main.c app_th.c app_time.c
  group mid
    ./src/mid/: mid_th.c mid_cli.c mid_dbg.c mid_rtc.c
  group hal
    ./src/hal/: hal_sht10.c bsp.c hal_cli.c hal_uart.c hal_ds3231.c
    ./src/hal/common/: i2c_bus.c
  group FWLIB
    ./src/STMLIB/startup/: cstartup.s
    ./src/STMLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c
  group FreeRTOS
    ./src/FreeRTOS/: list.c queue.c tasks.c timers.c
    ./src/FreeRTOS/portable/MemMang/: heap_2.c
    ./src/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
